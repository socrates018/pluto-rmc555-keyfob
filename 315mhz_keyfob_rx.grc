options:
  parameters:
    author: Sokratis Soutsiou
    generate_options: qt_gui
    id: keyfob_315mhz_rx
    output_language: python
    title: Keyfob Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '305'
    step: '0.1'
    stop: '325'
    value: '311.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: keyfob_pulses.dat
    type: float
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.02'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="RMC555 Pulse Decoder",
                  in_sig=[np.float32],
                  out_sig=[]
              )

              self.message_port_register_out(pmt.intern("out"))

              self.last_state = 0
              self.count = 0
              self.bits = ""


          def general_work(self, input_items, output_items):

              data = input_items[0]

              for sample in data:

                  state = 1 if sample > 0.5 else 0

                  self.count += 1

                  # Falling edge = end of HIGH pulse
                  if self.last_state == 1 and state == 0:

                      pulse = self.count
                      self.decode_pulse(pulse)

                      self.count = 0

                  self.last_state = state


              self.consume(0, len(data))
              return 0


          def decode_pulse(self, pulse):

              # Frame sync
              if pulse > 4000:

                  if len(self.bits) > 0:
                      print("FRAME:", self.bits)

                      msg = pmt.string_to_symbol(self.bits)

                      self.message_port_pub(
                          pmt.intern("out"),
                          msg
                      )

                  self.bits = ""
                  return


              # Ignore noise
              if pulse > 2000:
                  return


              # Pulse decoding
              if 200 <= pulse <= 350:
                  self.bits += "0"

              elif 350 < pulse <= 650:
                  self.bits += "1"

              else:
                  print("UNKNOWN PULSE:", pulse)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '4'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100e3, 20e3)
    type: ccf
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int (freq*1e6)
    gain1: '''hybrid'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_fff
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '50000'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_0, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, out, blocks_message_debug_0, print]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
